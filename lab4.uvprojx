# Keil uVision project lab4.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exemplo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: startup.s utils.s main.c tm4c1294ncpdt.h gpio.c gpio.h lcd.c lcd.h utils.h conversorAD.c motorDC.c timer.c uart.c conversorAD.h motorDC.h timer.h uart.h
